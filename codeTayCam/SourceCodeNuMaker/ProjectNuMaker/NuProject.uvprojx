# Keil uVision project NuProject.uvprojx, settings and files
target NuProject (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NUC131SD2AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x11000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: NuProject
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Library\CMSIS\Include;..\Library\Device\Nuvoton\NUC131\Include;..\Library\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../Library/Device/Nuvoton/NUC131/Source/: system_NUC131.c
    ../Library/Device/Nuvoton/NUC131/Source/ARM/: startup_NUC131.s
  group User
    ./: main.c
  group library
    ../Library/StdDriver/src/: clk.c gpio.c sys.c uart.c retarget.c adc.c
